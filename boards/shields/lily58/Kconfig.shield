## boards/shields/lily58/Kconfig.shield
```kconfig
config SHIELD_MY_KEYBOARD_DONGLE
    def_bool $(shields_list_contains,my_keyboard_dongle)
```
